# Keil uVision project project.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: --gnu
  c include: ..\src;..\lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../lib/: stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h system_stm32f10x.h startup_stm32f10x_md.s
  group src
    ../src/: adc.c binary.c cli.c config.c digital.c fet.c getbuildnum.c main.c misc.c ow.c pwm.c rcc.c run.c serial.c timer.c adc.h binary.h buildnum.h cli.h config.h core_cm3.h digital.h fet.h getbuildnum.h main.h misc.h ow.h pwm.h rcc.h run.h serial.h timer.h watchdog.c watchdog.h
software components: CMSIS:CORE 5.1.2
